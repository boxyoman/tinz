# Repository boxyoman/tinz

File README.md:

# The TINZ Development Board
TINZ (or tinz) is a recursive acronym that stands for Tinz Is Not Zybo.
The reason for this naming is because Tinz is, in fact, not Zybo. This name was
invented by our good friend Ed Almasy.

## EAGLE design board/tinz.brd

Parts:
C1, C4, C6, C13, C32, C40, C42, C45, C46, C49, C51: 10uF; C0603
C2, C3, C12, C16: 0.01uF; C0603
C5, C36, C38: 4.7uF; C0603
C7, C14: 1uF; C0603
C8, C9, C10, C11, C15, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C33, C34, C35, C37, C39, C41, C44, C47, C48, C50, C52: 0.1uF; C0603
C43: 2.2uF; C0603
C53, C54: 56pF; C0603
D1: CDBU0520; SOD-523
IC1: 74LVC1G14DCK; SC70-5
JP1, JP2, JP3, JP4, JP5: M06SILK_FEMALE_PTH; 1X06
LED1, LED2, LED3, LED4: Green; SML0603
LED5, LED6: Amber; SML0603
LED7, LED8: Red; SML0603
R1, R2: 1M; R0603
R3: 357K; R0603
R4, R5, R16, R37, R38, R39, R40, R41, R42, R44, R45: 100; R0603
R6: 210K; R0603
R7, R8: 0.1; R0603
R9, R28: 2.2K; R0603
R10, R11, R12, R13, R17, R19, R24, R26, R27: 10K; R0603
R18: 0; R0603
R29: 12K; R0603
R43: 25; R0603
R46, R47: 1k; R0603
U2: ATSAM3S4AA-AU; QFP50P900X900X160-48N
U$1: FT2232H; LQFP-ST-64-2
U$2: ICE40HX1K; TQFP144
U$3: N25Q032A; SOIC8
U$4: LT3030EFE#TRPBF; TSSOP20
U$5: 93LC56C-I/SN; SOIC127P600X175-8N
U$6: DX07S0; DX07S024JJ2
U$7: SG-636PCE; SG-636
U$8: ECO32; 4-SMD

Connections:
12MHZ: U$1.2 (OSCI), U$2.129 (GBIN0/PIO0_00), U$7.3 (FO)
+1.2V: C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, R7.1, R16.1, U$2.27 (VCC_02), U$2.51 (VCC_01), U$2.92 (VCC_03), U$2.111 (VCC_04)
+1.22V: C3.1, C5.1, R5.2, R7.2, U$4.7 (OUT2_A), U$4.8 (OUT2_B), U$4.10 (ADJ2)
+3.3V: C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C41.1, C42.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, D1.A, JP1.6, JP2.6, JP3.6, JP4.6, JP5.6, R8.1, R10.2, R11.2, R12.2, R13.1, R19.1, R24.2, R26.2, R27.2, R28.2, R43.1, R45.2, R46.2, R47.2, U2.7 (VDDIN), U2.13 (VDDIO_2), U2.33 (VDDIO_3), U2.47 (VDDIO), U$1.4 (VPHY), U$1.9 (VPLL), U$1.20 (VCCIO3), U$1.31 (VCCIO2), U$1.42 (VCCIO1), U$1.50 (VREGIN), U$1.56 (VCCIO0), U$2.6 (VCCIO3_01), U$2.30 (VCCIO3_02), U$2.46 (VCCIO2_01), U$2.57 (VCCIO2_02), U$2.72 (SPI_VCC), U$2.89 (VCCIO1_01), U$2.100 (VCCIO1_02), U$2.123 (VCCIO0_02), U$2.133 (VCCIO0_01), U$3.8 (VCC), U$5.6 (ORG), U$5.8 (VCC), U$7.4 (VCC)
+3.31V: C2.1, C4.1, R3.2, R4.2, R8.2, U$4.3 (OUT1_A), U$4.4 (OUT1_B)
AD0: JP4.2, U2.9 (PA17/PGMD5/AD0)
AD1: JP5.2, U2.10 (PA18/PGMD6/AD1)
AD2: JP4.1, U2.11 (PA19/PGMD7/AD2)
AD3: JP5.1, U2.12 (PA20/AD3)
AD4: JP4.3, U2.3 (PB0/AD4)
AD5: JP5.3, U2.4 (PB1/AD5)
ADVREF: JP4.4, U2.1 (ADVREF)
CDONE: R13.2, U$1.23 (ACBUS6), U$2.65 (CDONE)
CRESET_B: R18.1, R19.2, U$1.24 (ACBUS7), U$2.66 (CRESET_B)
DTRN: IC1.2 (I), U$1.43 (BDBUS4)
D_N: U$1.7 (DM), U$6.A7 (DN), U$6.B7 (DN)
D_P: U$1.8 (DP), U$6.A6 (DP), U$6.B6 (DP)
FT_EECLK: R11.1, U$1.62 (EECLK), U$5.2 (CLK)
FT_EECS: R10.1, U$1.63 (EECS), U$5.1 (CS)
FT_EEDATA: R9.1, U$1.61 (EEDATA), U$5.3 (DI)
GND: C1.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, IC1.3 (GND), JP1.5, JP2.5, JP3.5, JP4.5, JP5.4, JP5.5, LED1.C, LED2.C, LED3.C, LED4.C, LED5.C, LED6.C, LED7.C, LED8.C, R4.1, R5.1, R6.1, R17.1, R18.2, U2.2 (GND_2), U2.34 (GND), U$1.1 (GND_7), U$1.5 (GND_6), U$1.10 (AGND), U$1.11 (GND_5), U$1.13 (TEST), U$1.15 (GND_4), U$1.25 (GND_3), U$1.35 (GND_2), U$1.47 (GND_1), U$1.51 (GND_0)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
GPIO0: U2.35 (PA1/PGMEN1), U$2.26 (PIO3_17/DP10B)
GPIO1: U2.36 (PA0/PGMEN0), U$2.25 (PIO3_16/DP10A)
IOA0: JP1.1, U$2.112 (PIO0_02)
IOA1: JP1.2, U$2.113 (PIO0_03)
IOA2: JP1.3, U$2.114 (PIO0_04)
IOA3: JP1.4, U$2.115 (PIO0_05)
IOB0: JP2.1, U$2.117 (PIO0_07)
IOB1: JP2.2, U$2.118 (PIO0_08)
IOB2: JP2.3, U$2.119 (PIO0_09)
IOB3: JP2.4, U$2.120 (PIO0_10)
IOC0: JP3.1, U$2.134 (PIO0_13)
IOC1: JP3.2, U$2.135 (PIO0_14)
IOC2: JP3.3, U$2.136 (PIO0_15)
IOC3: JP3.4, U$2.137 (PIO0_16)
LED1: R37.1, U$2.95 (PIO1_10)
LED2: R38.1, U$2.96 (PIO1_11)
LED3: R39.1, U$2.97 (PIO1_12)
LED4: R40.1, U$2.98 (PIO1_13)
LED5: R42.1, U2.27 (PA5/PGMRDY)
LED6: R41.1, U2.24 (PA7/XIN32/PGMNVALID)
MISO: U$1.18 (ACBUS2), U$2.68 (PIOS_01/SPI_SI), U$3.2 (DQ1)
MOSI: U$1.17 (ACBUS1), U$2.67 (PIOS_02/SPI_SO), U$3.5 (DQ0)
M_MISO: U2.19 (PA12/PGMD0), U$2.47 (PIO2_12)
M_MOSI: U2.17 (PA13/PGMD1), U$2.48 (PIO2_13)
M_SPCK: U2.16 (PA14/PGMD2), U$2.49 (GBIN5/PIO2_01)
unnamed: R1.1, U$4.19 (PWRGD1)
unnamed: R2.1, U$4.12 (PWRGD2)
unnamed: C3.2, U$4.9 (BYP2)
unnamed: C2.2, U$4.2 (BYP1)
unnamed: R3.1, R6.2, U$4.1 (ADJ1)
unnamed: D1.C, U$2.108 (VPP_2V5)
unnamed: IC1.4 (O), U2.42 (ERASE/PB12)
unnamed: C31.2, C32.2, U$2.35 (PLLGND)
unnamed: R9.2, R12.1, U$5.4 (DO)
unnamed: C31.1, C32.1, R16.2, U$2.36 (PLLVCC)
unnamed: R17.2, U$2.77 (TRST_B)
unnamed: R28.1, U$1.14 (!RESET)
unnamed: R29.1, U$1.6 (REF)
unnamed: R27.1, U$3.7 (HOLD#/DQ3)
unnamed: C39.2, C40.2, R29.2
unnamed: LED4.A, R40.2
unnamed: LED3.A, R39.2
unnamed: LED2.A, R38.2
unnamed: LED1.A, R37.2
unnamed: LED8.A, R44.2
unnamed: LED6.A, R42.2
unnamed: LED5.A, R41.2
unnamed: LED7.A, R43.2
unnamed: R45.1, U$7.1 (OE)
SCK: R26.1, U$1.16 (ACBUS0), U$2.70 (PIOS_00/SPI_SCK), U$3.6 (C)
SPI_NPCS0: U2.20 (PA11/PGMM3), U$2.45 (PIO2_11)
SS: R24.1, U$1.21 (ACBUS4), U$2.71 (PIOS_03/SPI_SS_B), U$3.1 (!S#)
TWCK0: R47.1, U2.28 (PA4/PGMNCMD), U$2.39 (PIO2_06)
TWD0: R46.1, U2.31 (PA3), U$2.38 (PIO2_05)
URXD0: U2.22 (PA9/PGMM1), U$1.38 (BDBUS0)
URXD1: U2.6 (PB3/AD7), U$2.9 (PIO3_08/DP03A)
UTXD0: U2.21 (PA10/PGMM2), U$1.39 (BDBUS1)
UTXD1: U2.5 (PB2/AD6), U$2.10 (PIO3_09/DP03B)
VBUS_5V: C1.1, R1.2, R2.2, R44.1, U$4.11 (!SHDN2!), U$4.13 (IN2_A), U$4.14 (IN2_B), U$4.17 (IN1_A), U$4.18 (IN1_B), U$4.20 (!SHDN1!), U$6.A4 (VBUS), U$6.A9 (VBUS), U$6.B4 (VBUS), U$6.B9 (VBUS)
VCC: IC1.5 (VCC)
VCC1_8FT: C39.1, C40.1, U$1.12 (VCORE2), U$1.37 (VCORE1), U$1.49 (VREGOUT), U$1.64 (VCORE0)
VDDOUT: C43.1, C44.1, U2.8 (VDDOUT), U2.18 (VDDCORE_2), U2.41 (VDDCORE), U2.48 (VDDPLL)
VPP_FAST: U$2.109 (VPP_FAST)
XIN: C53.1, U2.46 (XIN/PB9/PGMCK), U$8.1 (IO2)
XOUT: C54.1, U2.45 (XOUT/PB8), U$8.3 (IO1)

Notes on the sheet:
Voltage Regulator
iCE VCC_0X bypass caps
EEPROM Bypass Caps
Unknown bypass caps
Unsure about most of the bypass cap and power pin stuff
iCE VCCIOX bypass caps
FPGA LEDs
MCU LEDs
12 MHz clock
Flash for FPGA
For VDDin
For VDDout
ADx and ADVREF still need connected to external pins
IO A
IO B
IO C
Analog IOs
dont include

Board: 2 copper layers, 101.6 x 80.0 mm, 111 parts (0 on the bottom side), 84 nets.

## Commit log

2015-10-29 Fixed design (learned how to markdown)
2015-10-29 Hopefully this looks better....
2015-10-29 Added the manufacturer and device number to the USB connector
2015-10-30 Changed USB controller
2015-10-30 Added the Element14 atmel library.
2015-10-30 Added ATSAM3S2CA-AU to the schematic.
2015-10-30 added a schemetic symbol for the FTDI chip.
2015-10-30 Added schematic symbol for iCE40HX1k-TQ144
2015-10-30 Changed name ;)
2015-10-30 Finished schematic, changed layout, & created package for the iCE40
2015-10-31 Started assigning pin numbers in the device model
2015-10-31 Added the FTDI package.
2015-10-31 Updated device list to include actually MCU we will use.
2015-10-31 Finished the device model of the iCE40
2015-10-31 Fixed typo for the flash device
2015-10-31 Fixed another typo on the device number for flash
2015-10-31 Removed the extra models
2015-10-31 Changed EEPROM to an updated version. Added library for microchip from element14.
2015-10-31 Added/finished flash memory device library
2015-11-03 Created block design
2015-11-03 Explained the project more
2015-11-03 Fixed a typo
2015-11-03 Fixed a grammatical error
2015-11-03 Removed "data" node name
2015-11-04 Added library for voltage regulator.
2015-11-04 Moved block diagram into folder.
2015-11-04 Change voltage regulator to use mm in the schematic.
    Who, in their right mind, sets the default to inches?
2015-11-04 Revert "Moved block diagram into folder."
    This reverts commit 414665dbfdef90d33d1733bc3a98bd02796f9459.
    Back to inches, and I don't like it.
2015-11-04 Making size schematic modification
2015-11-04 Move block designs into folder called block.
2015-11-04 Deleted old block design.
2015-11-04 Updated schematic layout and unit of measure
2015-11-04 Changed layout and unit of measure
2015-11-04 Added all device schematics in the main schematic
2015-11-04 Added some grounds. Updated voltage regulator.
2015-11-04 Changed types of pins in the voltage regulator.
2015-11-04 Changed the USB type-C connector.
2015-11-04 Finished the voltage reg circuit and added parts
2015-11-04 Fixed merge conflict
2015-11-04 Added number of descrete components
2015-11-04 Added generic bypass caps
2015-11-05 Wired the EEPROM to the FDTI
2015-11-05 Added iCE bypass caps and diode
2015-11-05 Moved some pins around for better efficiency
2015-11-05 Initial commit for USB type c
2015-11-05 Finished the power pins to the iCE and started on others
2015-11-06 Created table with parts
2015-11-06 Added holes for the USB-C connector.
2015-11-06 Connected the SPI flash
2015-11-06 Finished up the current FTDI and iCE connection
2015-11-06 Almost finished with USB-C.
2015-11-06 Added some DigiKey part numbers
2015-11-06 Added more Digikey part number
2015-11-06 Updated USB-C. Added USB-C to schematic, and the ATSAM3S.
2015-11-08 Added missing resistors, and pushbuttons.
2015-11-09 Added button part numbers and descriptions
2015-11-09 Added LEDs to the device table.
2015-11-09 Changed LEDs in the device table.
2015-11-09 Added blue and red LEDs to device table.
2015-11-09 Removed blue LEDs.
2015-11-09 Added connectors
2015-11-09 Added library for oscillator.
2015-11-10 Added crystal to schematic.
2015-11-11 Added a comment.
2015-11-11 Added a todo list :)
2015-11-11 Changed package type for all resistors and caps.
2015-11-11 Added bypass caps for MCU.
2015-11-11 Updated schematice comments.
2015-11-11 Change resistor/cap size and companies
2015-11-11 Fixed the 2.2uF cap package/company
2015-11-11 Added crystal for the MCU.
2015-11-11 Added a 56pF cap to the device list
2015-11-11 Added crystal for MCU to device table.
2015-11-11 Added new LED companies/packages
2015-11-13 Changed the LISP function at the bottom of todo
2015-11-13 Changed some resistors in the device table
2015-11-13 Added some connections between the FPGA and the MCU.
2015-11-16 Added GPIO between the MCU and the FPGA.
2015-11-16 Fixed bug with NPCSx connections.
2015-11-18 Connected the TWI interface.
2015-11-18 Added ADVREF.
2015-11-18 Added Vddpll wire.
2015-11-18 Added the connectors
2015-11-20 Started the PCB.
2015-11-23 Worked on BCP more.
2015-11-23 Changed the diode package
2015-11-23 Everything but the bypass caps are on the board.
2015-11-24 Ignore emacs backup files
2015-12-02 Changed crystal for arm.
2015-12-02 Order list
2015-12-02 Fixed bug.
2015-12-02 Added all the bypass caps to the PCB
2015-12-04 Removed orderThings file.
2015-12-04 Made some changes to the PCB.
2015-12-04 Added somemore traces.
2015-12-08 Updated block design
2015-12-08 Updated connection table.
2015-12-09 Modified PCB.
2015-12-09 changed name of schematic and pcb.
2015-12-09 Change the LICENSE file a little...
2015-12-12 Continued PCB, fixed bug.
2015-12-12 Fixed device table.
2015-12-13 Worked on PCB more.
2015-12-14 More work on PCB.
2015-12-14 Updated USBC connector.
2015-12-14 Got the flash all wired up on the PCB.
2015-12-14 Made the USBC connector better.
2015-12-14 Added updated USB connector to schematic and PCB.
2015-12-14 Added net class for USB.
2016-01-07 Routed USB stuff.
2016-01-07 Untwisted most of the wires between the MCU and GPIO.
2016-01-07 Just some PCB stuff.
2016-01-10 Ran the TWI and UART traces
2016-01-11 Routed SPI
2016-01-13 IDK.
2016-01-13 Some more wires added.
2016-01-21 Added sparkfun lib.
2016-01-21 Added the ecx crystal oscillator.
2016-01-21 new GND layer
2016-01-21 Got most of it done!
2016-01-21 I think the board is finished.
2016-01-21 Approved somethings in the schematic
2016-01-29 Made the silk screen better.
2016-01-29 Made the 5V wire larger.
2016-02-01 IDK...
2016-02-03 Changed shape of vias. Fixed some issues.
2016-02-04 switched to sparkfuns drc.
2016-02-04 Fixed some design rule issues.
2016-02-04 Some minor changes.
2016-02-19 Fixed drill hole USB bug...
2016-02-19 Better holes for the USB connector.
2016-02-19 Updated the USB lib in schematic and board.
2016-02-25 Fixed some more bugs with USB-C
2016-02-25 Added updated USB-C to PCB
2016-03-21 Fixed some bugs.
2016-03-22 Added cutout of USB connector.
2016-03-23 Updated todo list
2016-04-20 Deployed 6f1e41f with MkDocs version: 0.15.3
2016-04-20 Updated sparkfun stuff.
2016-04-20 Using MkDoc to build site.
2016-04-20 Deployed 1f1f7cb with MkDocs version: 0.15.3
2016-04-20 Added new theme.
2016-04-20 Updated Block Diagram.
2016-04-24 Added some new pages.
2016-04-24 Deployed 4b5e66f with MkDocs version: 0.15.3
2016-04-24 Added content to board and FPGA.
2016-04-24 Deployed c0fbf26 with MkDocs version: 0.15.3
2016-04-25 Added more content.
2016-04-25 Deployed 811d140 with MkDocs version: 0.15.3
2016-04-28 Updated board info.
2016-04-28 Added io section.
2016-04-28 Deployed 9a726e9 with MkDocs version: 0.15.3
2016-04-29 Added info about the analog pins.
2016-04-29 Deployed 3231bda with MkDocs version: 0.15.3
2016-05-04 Added an inverter chip.
2016-05-04 Fixed LED size issue.
2016-05-05 PMOD changed to GPIO.
2016-05-05 Updated README.
2016-05-05 Minor fixes for the docs.
2016-05-05 Deployed 000928b with MkDocs version: 0.15.3

Notices in the files:
parts and their libraries:
SparkFun-Connectors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
